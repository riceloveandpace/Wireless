# Keil uVision project stm32_bare_metal_api.uvprojx, settings and files
target tm4c123_bare_metal_api (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_bare_metal_api
  AfterMake: fromelf --bin --output .\Objects\stm32_bare_metal_api.bin .\Objects\stm32_bare_metal_api.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BARE_METAL rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c include: ..\..\src\api;..\..\src\arch\ARM\tivaware\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --callgraph
  group Source file
    ../../src/api/: hex_bytes.c serial_reader.c serial_reader_l3.c tm_reader.c tmr_param.c tmr_strerror.c tmr_utils.c osdep_tm4c123gh5pm.c serial_transport_tm4c123gh6pm.c
    ../../src/samples/: read.c
  group Libraries
    ../../src/arch/ARM/tivaware/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.1
